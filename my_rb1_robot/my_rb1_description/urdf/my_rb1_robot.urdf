Commit message: Task 1 ANswer

File: my_rb1_robot/my_rb1_description/urdf/my_rb1_robot.urdf (robot description, URDF)
Before this commit: robot robot, 7 links, 6 joints
Links:
- link link_base_link: geometry collision box size=0 0 0; visual box size=0 0 0
